# Repository robin7331/pixel-pump-motor-board

File README.md:

# Pixel Pump Motor Board Rev 5
`KiCad 6.0.11`

See iBOM [rendered as Page](https://htmlpreview.github.io/?https://github.com/robin7331/pixel-pump-motor-board/blob/main/bom/ibom.html) via GitHub Pages

## KiCad design pixel-pump-motor-board.kicad_pcb

Parts:
C1: 100N 25V; CP_EIA-3216-18_Kemet-A; MPN T491A104K035AT
D1: SOD4007; D_SOD-123F; MPN SOD4007
FID1, FID2, FID3: Fiducial; Fiducial_0.5mm_Mask1mm
J1: BM04B-SRSS-TBT; MPN BM04B-SRSS-TBT(LF)(SN)
J2, J3: motor-connector; motor-mount
J5, J7, J8, J11: Motor Chassis GND; TestPoint_Pad_2.0x2.0mm
Q1: STN4NF20L; SOT223; PARTNO 497-10779-1-ND
R1: 160R; R_0603_1608Metric; MPN 160 0603
R2: 100K; R_0603_1608Metric; MPN 100k 0603
T1, T2: Tab
U1: 250X15W104MV4E; MPN 250X15W104MV4E

Connections:
+12V: C1.1, D1.1 (K), J1.1, J2.1 (motor), U1.2
GND: C1.2, J1.3, J1.4, J5.1, J7.1, J8.1, J11.1, Q1.3, R2.2, U1.3, U1.4
unnamed: D1.2 (A), J3.1 (motor), Q1.2, Q1.T, U1.1
unnamed: Q1.1, R1.1, R2.1
PWM: J1.2, R1.2

Board: 2 copper layers, 28.2 x 28.2 mm, 20 parts (4 on the bottom side), 5 nets.

Other parts of the board:
kibuzzard-62EBC13F: G***; kibuzzard-62EBC13F
kibuzzard-62EBC161: G***; kibuzzard-62EBC161

## Commit log

2021-08-02 Initial
2021-08-02 Finished
2021-08-02 Step export
2021-08-03 Finish motor board
2021-08-03 Cleanup and generate iBOM
2021-08-03 Add gitignore
2021-08-06 Minor adjustments and iBOM generation
2021-08-06 Generate rev2 gerbers
2022-01-11 Upgrade project to Kicad 6
2022-01-16 Update gitignore
2022-01-16 Cleanup
2022-01-16 Add panelize scripts
2022-01-16 Update iBOM
2022-02-18 Generate iBOM
2022-04-29 Fix bemf pin
2022-04-29 Reduce stiffness of mousebites
2022-04-29 Revision bump
2022-08-04 Remove bemf and add robins logo
2022-08-04 Bump rev
2022-12-04 Remove zip
2022-12-04 Update val to BM04B
2022-12-22 iBOM
2023-01-30 Add fiducials, fix SMD/THT, Bump rev to 4
2023-01-31 Add 3rd fiducial
2023-02-01 Remove unneeded VIA
2023-02-13 Remove gerbers from gitignore
2023-02-13 Add kikit tabs
2023-02-13 Panelize
2023-02-13 Add tabs to schematics
2023-02-13 Update panel and gerbers for 3 x 3
2023-02-23 Small things
2023-02-23 Fixed footprints
2023-02-24 Update panel config
2023-02-24 Add BM04B footprint
2023-03-10 Finalized adjusted CSV file
2023-03-10 Fixed connector translation issue and created new panels
2023-03-23 Fix panel

Notices in the files:
parts and their libraries:
Copyright 2021 Accelerated Designs. All rights reserved.
